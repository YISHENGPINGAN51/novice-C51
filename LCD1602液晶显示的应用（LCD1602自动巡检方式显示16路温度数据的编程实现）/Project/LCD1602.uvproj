# Keil uVision project LCD1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LCD1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Source/: main.c delay.c delay.h LCD1602.c LCD1602.h Key.c Key.h menu.c menu.h
