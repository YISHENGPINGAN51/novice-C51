# Keil uVision project DS18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DS18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Source/: delay.c delay.h LCD1602.c LCD1602.h OneWire.c OneWire.h DS18B20.c DS18B20.h main2.c menu.c menu.h
